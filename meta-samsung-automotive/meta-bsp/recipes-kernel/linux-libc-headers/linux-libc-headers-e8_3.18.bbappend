#SRC_URI := "https_kerberos://artifactory.tttech.com/stage-1/tttech/automotive_networks/adas/ADAS_Exynos/linux-samsung-e8/linux-samsung-e8.tar.gz"
#SRC_URI[md5sum] = "33a564bfb16aa32cf17909bf1d4f63eb"
